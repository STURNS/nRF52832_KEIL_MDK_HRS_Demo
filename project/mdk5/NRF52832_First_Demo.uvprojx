# Keil uVision project NRF52832_First_Demo.uvprojx, settings and files
target NRF52832 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NRF52832_First_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10040,CONFIG_GPIO_AS_PINRESET,NRF52,NRF52832_XXAA,NRF_SD_BLE_API_VERSION,SOFTDEVICE_PRESENT,S132,SWI_DISABLE0,__STACK_SIZE=8192,__HEAP_SIZE=8192
  c include: ..\config;..\..\components;..\..\components\802_15_4\api\HAL;..\..\components\802_15_4\api\HAL\nrf52_soc;..\..\components\802_15_4\api\MAC;..\..\components\802_15_4\api\PHY;..\..\components\802_15_4\api\RAL;..\..\components\802_15_4\api\RAL\nrf52_soc;..\..\components\802_15_4\api\SecAL;..\..\components\802_15_4\api\SysAL;..\..\components\802_15_4\raw;..\..\components\802_15_4\secure;..\..\components\ant\ant_channel_config;..\..\components\ant\ant_encryption;..\..\components\ant\ant_fs;..\..\components\ant\ant_key_manager;..\..\components\ant\ant_key_manager\config;..\..\components\ant\ant_profiles\ant_bpwr;..\..\components\ant\ant_profiles\ant_bpwr\pages;..\..\components\ant\ant_profiles\ant_bpwr\simulator;..\..\components\ant\ant_profiles\ant_bpwr\utils;..\..\components\ant\ant_profiles\ant_bsc;..\..\components\ant\ant_profiles\ant_bsc\pages;..\..\components\ant\ant_profiles\ant_bsc\simulator;..\..\components\ant\ant_profiles\ant_bsc\utils;..\..\components\ant\ant_profiles\ant_common\ant_request_controller;..\..\components\ant\ant_profiles\ant_common\pages;..\..\components\ant\ant_profiles\ant_hrm;..\..\components\ant\ant_profiles\ant_hrm\pages;..\..\components\ant\ant_profiles\ant_hrm\simulator;..\..\components\ant\ant_profiles\ant_hrm\utils;..\..\components\ant\ant_profiles\ant_sdm;..\..\components\ant\ant_profiles\ant_sdm\pages;..\..\components\ant\ant_profiles\ant_sdm\simulator;..\..\components\ant\ant_profiles\ant_sdm\utils;..\..\components\ant\ant_search_config;..\..\components\ant\ant_state_indicator;..\..\components\ble\ble_advertising;..\..\components\ble\ble_db_discovery;..\..\components\ble\ble_dtm;..\..\components\ble\ble_link_ctx_manager;..\..\components\ble\ble_racp;..\..\components\ble\ble_radio_notification;..\..\components\ble\ble_services\ble_ancs_c;..\..\components\ble\ble_services\ble_ans_c;..\..\components\ble\ble_services\ble_bas;..\..\components\ble\ble_services\ble_bps;..\..\components\ble\ble_services\ble_cscs;..\..\components\ble\ble_services\ble_cts_c;..\..\components\ble\ble_services\ble_dfu;..\..\components\ble\ble_services\ble_dis;..\..\components\ble\ble_services\ble_escs;..\..\components\ble\ble_services\ble_gls;..\..\components\ble\ble_services\ble_hids;..\..\components\ble\ble_services\ble_hrs;..\..\components\ble\ble_services\ble_hts;..\..\components\ble\ble_services\ble_ias;..\..\components\ble\ble_services\ble_ias_c;..\..\components\ble\ble_services\ble_ipsp;..\..\components\ble\ble_services\ble_lbs;..\..\components\ble\ble_services\ble_lbs_c;..\..\components\ble\ble_services\ble_lls;..\..\components\ble\ble_services\ble_nus;..\..\components\ble\ble_services\ble_nus_c;..\..\components\ble\ble_services\ble_rscs;..\..\components\ble\ble_services\ble_rscs_c;..\..\components\ble\ble_services\ble_tps;..\..\components\ble\ble_services\eddystone;..\..\components\ble\ble_services\experimental_ble_lns;..\..\components\ble\ble_services\experimental_ble_ots;..\..\components\ble\ble_services\experimental_gatts_c;..\..\components\ble\ble_services\experimental_nrf_ble_cgms;..\..\components\ble\ble_services\experimental_nrf_ble_ots_c;..\..\components\ble\ble_services\nrf_ble_bms;..\..\components\ble\common;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\nrf_ble_gq;..\..\components\ble\nrf_ble_qwr;..\..\components\ble\nrf_ble_scan;..\..\components\ble\peer_manager;..\..\components\boards;..\..\components\drivers_nrf\radio_config;..\..\components\drivers_nrf\sdio;..\..\components\drivers_nrf\sdio\config;..\..\components\drivers_nrf\spi_master;..\..\components\drivers_nrf\twi_master\deprecated;..\..\components\drivers_nrf\twi_master\deprecated\config;..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\balloc;..\..\components\libraries\block_dev;..\..\components\libraries\block_dev\empty;..\..\components\libraries\block_dev\qspi;..\..\components\libraries\block_dev\ram;..\..\components\libraries\block_dev\sdc;..\..\components\libraries\bootloader;..\..\components\libraries\bootloader\ble_dfu;..\..\components\libraries\bootloader\dfu;..\..\components\libraries\bootloader\serial_dfu;..\..\components\libraries\bsp;..\..\components\libraries\button;..\..\components\libraries\cli;..\..\components\libraries\cli\ble_uart;..\..\components\libraries\cli\cdc_acm;..\..\components\libraries\cli\rtt;..\..\components\libraries\cli\uart;..\..\components\libraries\crc16;..\..\components\libraries\crc32;..\..\components\libraries\crypto;..\..\components\libraries\crypto\backend\cc310;..\..\components\libraries\crypto\backend\cc310_bl;..\..\components\libraries\crypto\backend\cifra;..\..\components\libraries\crypto\backend\mbedtls;..\..\components\libraries\crypto\backend\micro_ecc;..\..\components\libraries\crypto\backend\nrf_hw;..\..\components\libraries\crypto\backend\nrf_sw;..\..\components\libraries\crypto\backend\oberon;..\..\components\libraries\crypto\backend\optiga;..\..\components\libraries\csense;..\..\components\libraries\csense_drv;..\..\components\libraries\delay;..\..\components\libraries\ecc;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_task_manager;..\..\components\libraries\fds;..\..\components\libraries\fifo;..\..\components\libraries\fstorage;..\..\components\libraries\gfx;..\..\components\libraries\gpiote;..\..\components\libraries\hardfault;..\..\components\libraries\hci;..\..\components\libraries\led_softblink;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\low_power_pwm;..\..\components\libraries\memobj;..\..\components\libraries\mem_manager;..\..\components\libraries\mpu;..\..\components\libraries\mutex;..\..\components\libraries\pwm;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\queue;..\..\components\libraries\ringbuf;..\..\components\libraries\scheduler;..\..\components\libraries\sdcard;..\..\components\libraries\sensorsim;..\..\components\libraries\sha256;..\..\components\libraries\simple_timer;..\..\components\libraries\slip;..\..\components\libraries\sortlist;..\..\components\libraries\spi_mngr;..\..\components\libraries\stack_guard;..\..\components\libraries\stack_info;..\..\components\libraries\strerror;..\..\components\libraries\svc;..\..\components\libraries\timer;..\..\components\libraries\twi_mngr;..\..\components\libraries\twi_sensor;..\..\components\libraries\uart;..\..\components\libraries\usbd;..\..\components\libraries\usbd\class\audio;..\..\components\libraries\usbd\class\cdc;..\..\components\libraries\usbd\class\cdc\acm;..\..\components\libraries\usbd\class\dummy;..\..\components\libraries\usbd\class\hid;..\..\components\libraries\usbd\class\hid\generic;..\..\components\libraries\usbd\class\hid\kbd;..\..\components\libraries\usbd\class\hid\mouse;..\..\components\libraries\usbd\class\msc;..\..\components\libraries\usbd\class\nrf_dfu_trigger;..\..\components\libraries\util;..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\components\nfc\ndef\connection_handover\common;..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\components\nfc\ndef\generic\message;..\..\components\nfc\ndef\generic\record;..\..\components\nfc\ndef\launchapp;..\..\components\nfc\ndef\parser\message;..\..\components\nfc\ndef\parser\record;..\..\components\nfc\ndef\text;..\..\components\nfc\ndef\uri;..\..\components\nfc\platform;..\..\components\nfc\t2t_lib;..\..\components\nfc\t2t_parser;..\..\components\nfc\t4t_lib;..\..\components\nfc\t4t_parser\apdu;..\..\components\nfc\t4t_parser\cc_file;..\..\components\nfc\t4t_parser\hl_detection_procedure;..\..\components\nfc\t4t_parser\tlv;..\..\components\proprietary_rf\esb;..\..\components\proprietary_rf\gzll;..\..\components\proprietary_rf\gzll\config;..\..\components\serialization\application\codecs\ant\serializers;..\..\components\serialization\application\codecs\ble\serializers;..\..\components\serialization\application\codecs\common;..\..\components\serialization\application\hal;..\..\components\serialization\application\transport;..\..\components\serialization\common;..\..\components\serialization\common\struct_ser\ant;..\..\components\serialization\common\struct_ser\ble;..\..\components\serialization\common\transport;..\..\components\serialization\common\transport\ser_phy;..\..\components\serialization\common\transport\ser_phy\config;..\..\components\serialization\connectivity;..\..\components\serialization\connectivity\codecs\ant\middleware;..\..\components\serialization\connectivity\codecs\ant\serializers;..\..\components\serialization\connectivity\codecs\ble\middleware;..\..\components\serialization\connectivity\codecs\ble\serializers;..\..\components\serialization\connectivity\codecs\common;..\..\components\serialization\connectivity\hal;..\..\components\softdevice\common;..\..\components\softdevice\mbr\headers;..\..\components\softdevice\s132\headers;..\..\components\softdevice\s132\headers\nrf52;..\..\components\toolchain\arm;..\..\components\toolchain\cmsis\dsp\Include;..\..\components\toolchain\cmsis\include;..\..\external\cifra_AES128-EAX;..\..\external\cJSON;..\..\external\fatfs\port;..\..\external\fatfs\src;..\..\external\fnmatch;..\..\external\fprintf;..\..\external\freertos\config;..\..\external\freertos\portable\ARM\nrf51;..\..\external\freertos\portable\ARM\nrf52;..\..\external\freertos\portable\CMSIS\nrf51;..\..\external\freertos\portable\CMSIS\nrf52;..\..\external\freertos\portable\GCC\nrf51;..\..\external\freertos\portable\GCC\nrf52;..\..\external\freertos\portable\IAR\nrf51;..\..\external\freertos\portable\IAR\nrf52;..\..\external\freertos\source\include;..\..\external\infineon\examples\ecdsa_utils;..\..\external\infineon\optiga\include\optiga;..\..\external\infineon\optiga\include\optiga\cmd;..\..\external\infineon\optiga\include\optiga\common;..\..\external\infineon\optiga\include\optiga\comms;..\..\external\infineon\optiga\include\optiga\dtls;..\..\external\infineon\optiga\include\optiga\ifx_i2c;..\..\external\infineon\optiga\include\optiga\pal;..\..\external\infineon\pal\nrf5x;..\..\external\lwip\doc\doxygen;..\..\external\lwip\src\apps\httpd;..\..\external\lwip\src\apps\snmp;..\..\external\lwip\src\include\lwip;..\..\external\lwip\src\include\lwip\apps;..\..\external\lwip\src\include\lwip\priv;..\..\external\lwip\src\include\lwip\prot;..\..\external\lwip\src\include\netif;..\..\external\lwip\src\include\netif\ppp;..\..\external\lwip\src\include\netif\ppp\polarssl;..\..\external\lwip\src\include\posix;..\..\external\lwip\src\include\posix\sys;..\..\external\lwip\src\port;..\..\external\lwip\src\port\arch;..\..\external\mbedtls\configs;..\..\external\mbedtls\doxygen\input;..\..\external\mbedtls\include\mbedtls;..\..\external\nano;..\..\external\nano-pb;..\..\external\nfc_adafruit_library;..\..\external\nrf_cc310\common;..\..\external\nrf_cc310\include;..\..\external\nrf_cc310_bl\include;..\..\external\nrf_oberon\include;..\..\external\nrf_oberon\include\mbedtls;..\..\external\nrf_tls;..\..\external\nrf_tls\mbedtls\dtls\config;..\..\external\nrf_tls\mbedtls\nrf_crypto\config;..\..\external\nrf_tls\mbedtls\tls\config;..\..\external\protothreads;..\..\external\protothreads\pt-1.4;..\..\external\segger_rtt;..\..\external\thedotfactory_fonts;..\..\external\tile\tile_lib;..\..\external\tile\tile_lib\crypto;..\..\external\tile\tile_lib\drivers;..\..\external\tile\tile_lib\modules;..\..\external\tile\tile_shim;..\..\external\tile\tile_shim\tile_assert;..\..\external\tile\tile_shim\tile_bdaddr;..\..\external\tile\tile_shim\tile_features;..\..\external\tile\tile_shim\tile_gatt_db;..\..\external\tile\tile_shim\tile_player;..\..\external\tile\tile_shim\tile_service;..\..\external\tile\tile_shim\tile_storage;..\..\external\utf_converter;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx;..\..\modules\nrfx\drivers;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\drivers\src;..\..\modules\nrfx\drivers\src\prs;..\..\modules\nrfx\hal;..\..\modules\nrfx\helpers;..\..\modules\nrfx\mdk;..\..\modules\nrfx\soc;..\..\modules\nrfx\templates;..\..\modules\nrfx\templates\nRF52832;..\..\project\config;..\..\project\mdk5\RTE;..\config;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\hal;..\..\external\mbedtls\include\mbedtls;..\..\external\mbedtls\include;..\..\external\nrf_oberon\include;..\..\external\nrf_oberon\
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20002218 size 0xdde8
  group Application
    ../../app/: main.c
  group Board Definition
    ../../components/boards/: boards.c
  group Board Suppot
    ../../components/libraries/bsp/: bsp.c
  group UTF8/UTF16 converter
    ../../external/utf_converter/: utf.c
  group nRF BLE
    ../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../components/ble/ble_advertising/: ble_advertising.c
    ../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    ../../components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c nrf_ble_lesc.c
    ../../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../components/ble/ble_services/experimental_gatts_c/: nrf_ble_gatts_c.c
    ../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../components/ble/nrf_ble_gq/: nrf_ble_gq.c
    ../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../components/ble/ble_services/ble_hrs/: ble_hrs.c
  group nRF Driver
    ../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power.c nrfx_uart.c nrfx_uarte.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../components/libraries/util/: app_error.c nrf_assert.c app_util_platform.c app_error_handler_keil.c app_error_weak.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../components/libraries/button/: app_button.c
    ../../components/libraries/scheduler/: app_scheduler.c
    ../../components/libraries/timer/: app_timer.c
    ../../components/libraries/crc16/: crc16.c
    ../../components/libraries/fds/: fds.c
    ../../components/libraries/hardfault/: hardfault_implementation.c
    ../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../components/libraries/atomic/: nrf_atomic.c
    ../../components/libraries/balloc/: nrf_balloc.c
    ../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../components/libraries/memobj/: nrf_memobj.c
    ../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../components/libraries/queue/: nrf_queue.c
    ../../integration/nrfx/legacy/: nrf_drv_rng.c
    ../../modules/nrfx/soc/: nrfx_atomic.c
    ../../modules/nrfx/drivers/src/: nrfx_rng.c
  group nrf_cryto
    ../../components/libraries/crypto/backend/optiga/: optiga_backend_utils.c
    ../../components/libraries/crypto/backend/nrf_hw/: nrf_hw_backend_init.c nrf_hw_backend_rng.c nrf_hw_backend_rng_mbedtls.c
    ../../components/libraries/crypto/: nrf_crypto_aead.c nrf_crypto_aes.c nrf_crypto_aes_shared.c nrf_crypto_ecc.c nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_eddsa.c nrf_crypto_error.c nrf_crypto_hash.c nrf_crypto_hkdf.c nrf_crypto_hmac.c nrf_crypto_init.c nrf_crypto_rng.c nrf_crypto_shared.c
    ../../components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
    ../../external/mbedtls/library/: aes.c ctr_drbg.c platform_util.c
    ../../external/nrf_cc310/lib/cortex-m4/hard-float/short-wchar/: nrf_cc310_0.9.13.lib
    ../../external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: oberon_mbedtls_3.0.5.lib
    ../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../components/libraries/mem_manager/: mem_manager.c
    ../../components/libraries/sortlist/: nrf_sortlist.c
  group nRF Log
    ../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF Segger RTT
    ../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group nrf SoftDevice
    ../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
target s132nrf52701 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.1
  cpu: as above
  output: s132_nrf52_7.0.1_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c include: ..\config;..\..\components;..\..\components\802_15_4\api\HAL;..\..\components\802_15_4\api\HAL\nrf52_soc;..\..\components\802_15_4\api\MAC;..\..\components\802_15_4\api\PHY;..\..\components\802_15_4\api\RAL;..\..\components\802_15_4\api\RAL\nrf52_soc;..\..\components\802_15_4\api\SecAL;..\..\components\802_15_4\api\SysAL;..\..\components\802_15_4\raw;..\..\components\802_15_4\secure;..\..\components\ant\ant_channel_config;..\..\components\ant\ant_encryption;..\..\components\ant\ant_fs;..\..\components\ant\ant_key_manager;..\..\components\ant\ant_key_manager\config;..\..\components\ant\ant_profiles\ant_bpwr;..\..\components\ant\ant_profiles\ant_bpwr\pages;..\..\components\ant\ant_profiles\ant_bpwr\simulator;..\..\components\ant\ant_profiles\ant_bpwr\utils;..\..\components\ant\ant_profiles\ant_bsc;..\..\components\ant\ant_profiles\ant_bsc\pages;..\..\components\ant\ant_profiles\ant_bsc\simulator;..\..\components\ant\ant_profiles\ant_bsc\utils;..\..\components\ant\ant_profiles\ant_common\ant_request_controller;..\..\components\ant\ant_profiles\ant_common\pages;..\..\components\ant\ant_profiles\ant_hrm;..\..\components\ant\ant_profiles\ant_hrm\pages;..\..\components\ant\ant_profiles\ant_hrm\simulator;..\..\components\ant\ant_profiles\ant_hrm\utils;..\..\components\ant\ant_profiles\ant_sdm;..\..\components\ant\ant_profiles\ant_sdm\pages;..\..\components\ant\ant_profiles\ant_sdm\simulator;..\..\components\ant\ant_profiles\ant_sdm\utils;..\..\components\ant\ant_search_config;..\..\components\ant\ant_state_indicator;..\..\components\ble\ble_advertising;..\..\components\ble\ble_db_discovery;..\..\components\ble\ble_dtm;..\..\components\ble\ble_link_ctx_manager;..\..\components\ble\ble_racp;..\..\components\ble\ble_radio_notification;..\..\components\ble\ble_services\ble_ancs_c;..\..\components\ble\ble_services\ble_ans_c;..\..\components\ble\ble_services\ble_bas;..\..\components\ble\ble_services\ble_bas_c;..\..\components\ble\ble_services\ble_bps;..\..\components\ble\ble_services\ble_cscs;..\..\components\ble\ble_services\ble_cts_c;..\..\components\ble\ble_services\ble_dfu;..\..\components\ble\ble_services\ble_dis;..\..\components\ble\ble_services\ble_dis_c;..\..\components\ble\ble_services\ble_escs;..\..\components\ble\ble_services\ble_gls;..\..\components\ble\ble_services\ble_hids;..\..\components\ble\ble_services\ble_hrs;..\..\components\ble\ble_services\ble_hrs_c;..\..\components\ble\ble_services\ble_hts;..\..\components\ble\ble_services\ble_ias;..\..\components\ble\ble_services\ble_ias_c;..\..\components\ble\ble_services\ble_ipsp;..\..\components\ble\ble_services\ble_lbs;..\..\components\ble\ble_services\ble_lbs_c;..\..\components\ble\ble_services\ble_lls;..\..\components\ble\ble_services\ble_nus;..\..\components\ble\ble_services\ble_nus_c;..\..\components\ble\ble_services\ble_rscs;..\..\components\ble\ble_services\ble_rscs_c;..\..\components\ble\ble_services\ble_tps;..\..\components\ble\ble_services\eddystone;..\..\components\ble\ble_services\experimental_ble_lns;..\..\components\ble\ble_services\experimental_ble_ots;..\..\components\ble\ble_services\experimental_gatts_c;..\..\components\ble\ble_services\experimental_nrf_ble_cgms;..\..\components\ble\ble_services\experimental_nrf_ble_ots_c;..\..\components\ble\ble_services\nrf_ble_bms;..\..\components\ble\common;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\nrf_ble_gq;..\..\components\ble\nrf_ble_qwr;..\..\components\ble\nrf_ble_scan;..\..\components\ble\peer_manager;..\..\components\boards;..\..\components\drivers_nrf\radio_config;..\..\components\drivers_nrf\sdio;..\..\components\drivers_nrf\sdio\config;..\..\components\drivers_nrf\spi_master;..\..\components\drivers_nrf\twi_master\deprecated;..\..\components\drivers_nrf\twi_master\deprecated\config;..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\balloc;..\..\components\libraries\block_dev;..\..\components\libraries\block_dev\empty;..\..\components\libraries\block_dev\qspi;..\..\components\libraries\block_dev\ram;..\..\components\libraries\block_dev\sdc;..\..\components\libraries\bootloader;..\..\components\libraries\bootloader\ble_dfu;..\..\components\libraries\bootloader\dfu;..\..\components\libraries\bootloader\serial_dfu;..\..\components\libraries\bsp;..\..\components\libraries\button;..\..\components\libraries\cli;..\..\components\libraries\cli\ble_uart;..\..\components\libraries\cli\cdc_acm;..\..\components\libraries\cli\rtt;..\..\components\libraries\cli\uart;..\..\components\libraries\crc16;..\..\components\libraries\crc32;..\..\components\libraries\crypto;..\..\components\libraries\crypto\backend\cc310;..\..\components\libraries\crypto\backend\cc310_bl;..\..\components\libraries\crypto\backend\cifra;..\..\components\libraries\crypto\backend\mbedtls;..\..\components\libraries\crypto\backend\micro_ecc;..\..\components\libraries\crypto\backend\nrf_hw;..\..\components\libraries\crypto\backend\nrf_sw;..\..\components\libraries\crypto\backend\oberon;..\..\components\libraries\crypto\backend\optiga;..\..\components\libraries\csense;..\..\components\libraries\csense_drv;..\..\components\libraries\delay;..\..\components\libraries\ecc;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_task_manager;..\..\components\libraries\fds;..\..\components\libraries\fifo;..\..\components\libraries\fstorage;..\..\components\libraries\gfx;..\..\components\libraries\gpiote;..\..\components\libraries\hardfault;..\..\components\libraries\hci;..\..\components\libraries\led_softblink;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\low_power_pwm;..\..\components\libraries\memobj;..\..\components\libraries\mem_manager;..\..\components\libraries\mpu;..\..\components\libraries\mutex;..\..\components\libraries\pwm;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\queue;..\..\components\libraries\ringbuf;..\..\components\libraries\scheduler;..\..\components\libraries\sdcard;..\..\components\libraries\sensorsim;..\..\components\libraries\sha256;..\..\components\libraries\simple_timer;..\..\components\libraries\slip;..\..\components\libraries\sortlist;..\..\components\libraries\spi_mngr;..\..\components\libraries\stack_guard;..\..\components\libraries\stack_info;..\..\components\libraries\strerror;..\..\components\libraries\svc;..\..\components\libraries\timer;..\..\components\libraries\twi_mngr;..\..\components\libraries\twi_sensor;..\..\components\libraries\uart;..\..\components\libraries\usbd;..\..\components\libraries\usbd\class\audio;..\..\components\libraries\usbd\class\cdc;..\..\components\libraries\usbd\class\cdc\acm;..\..\components\libraries\usbd\class\dummy;..\..\components\libraries\usbd\class\hid;..\..\components\libraries\usbd\class\hid\generic;..\..\components\libraries\usbd\class\hid\kbd;..\..\components\libraries\usbd\class\hid\mouse;..\..\components\libraries\usbd\class\msc;..\..\components\libraries\usbd\class\nrf_dfu_trigger;..\..\components\libraries\util;..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\components\nfc\ndef\connection_handover\common;..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\components\nfc\ndef\generic\message;..\..\components\nfc\ndef\generic\record;..\..\components\nfc\ndef\launchapp;..\..\components\nfc\ndef\parser\message;..\..\components\nfc\ndef\parser\record;..\..\components\nfc\ndef\text;..\..\components\nfc\ndef\uri;..\..\components\nfc\platform;..\..\components\nfc\t2t_lib;..\..\components\nfc\t2t_parser;..\..\components\nfc\t4t_lib;..\..\components\nfc\t4t_parser\apdu;..\..\components\nfc\t4t_parser\cc_file;..\..\components\nfc\t4t_parser\hl_detection_procedure;..\..\components\nfc\t4t_parser\tlv;..\..\components\proprietary_rf\esb;..\..\components\proprietary_rf\gzll;..\..\components\proprietary_rf\gzll\config;..\..\components\serialization\application\codecs\ant\serializers;..\..\components\serialization\application\codecs\ble\serializers;..\..\components\serialization\application\codecs\common;..\..\components\serialization\application\hal;..\..\components\serialization\application\transport;..\..\components\serialization\common;..\..\components\serialization\common\struct_ser\ant;..\..\components\serialization\common\struct_ser\ble;..\..\components\serialization\common\transport;..\..\components\serialization\common\transport\ser_phy;..\..\components\serialization\common\transport\ser_phy\config;..\..\components\serialization\connectivity;..\..\components\serialization\connectivity\codecs\ant\middleware;..\..\components\serialization\connectivity\codecs\ant\serializers;..\..\components\serialization\connectivity\codecs\ble\middleware;..\..\components\serialization\connectivity\codecs\ble\serializers;..\..\components\serialization\connectivity\codecs\common;..\..\components\serialization\connectivity\hal;..\..\components\softdevice\common;..\..\components\softdevice\mbr\headers;..\..\components\softdevice\s132\headers;..\..\components\softdevice\s132\headers\nrf52;..\..\components\toolchain\arm;..\..\components\toolchain\cmsis\dsp\Include;..\..\components\toolchain\cmsis\include;..\..\external\cifra_AES128-EAX;..\..\external\cJSON;..\..\external\fatfs\port;..\..\external\fatfs\src;..\..\external\fnmatch;..\..\external\fprintf;..\..\external\freertos\config;..\..\external\freertos\portable\ARM\nrf51;..\..\external\freertos\portable\ARM\nrf52;..\..\external\freertos\portable\CMSIS\nrf51;..\..\external\freertos\portable\CMSIS\nrf52;..\..\external\freertos\portable\GCC\nrf51;..\..\external\freertos\portable\GCC\nrf52;..\..\external\freertos\portable\IAR\nrf51;..\..\external\freertos\portable\IAR\nrf52;..\..\external\freertos\source\include;..\..\external\infineon\examples\ecdsa_utils;..\..\external\infineon\optiga\include\optiga;..\..\external\infineon\optiga\include\optiga\cmd;..\..\external\infineon\optiga\include\optiga\common;..\..\external\infineon\optiga\include\optiga\comms;..\..\external\infineon\optiga\include\optiga\dtls;..\..\external\infineon\optiga\include\optiga\ifx_i2c;..\..\external\infineon\optiga\include\optiga\pal;..\..\external\infineon\pal\nrf5x;..\..\external\lwip\doc\doxygen;..\..\external\lwip\src\apps\httpd;..\..\external\lwip\src\apps\snmp;..\..\external\lwip\src\include\lwip;..\..\external\lwip\src\include\lwip\apps;..\..\external\lwip\src\include\lwip\priv;..\..\external\lwip\src\include\lwip\prot;..\..\external\lwip\src\include\netif;..\..\external\lwip\src\include\netif\ppp;..\..\external\lwip\src\include\netif\ppp\polarssl;..\..\external\lwip\src\include\posix;..\..\external\lwip\src\include\posix\sys;..\..\external\lwip\src\port;..\..\external\lwip\src\port\arch;..\..\external\mbedtls\configs;..\..\external\mbedtls\doxygen\input;..\..\external\mbedtls\include\mbedtls;..\..\external\nano;..\..\external\nano-pb;..\..\external\nfc_adafruit_library;..\..\external\nrf_cc310\common;..\..\external\nrf_cc310\include;..\..\external\nrf_cc310_bl\include;..\..\external\nrf_oberon\include;..\..\external\nrf_oberon\include\mbedtls;..\..\external\nrf_tls;..\..\external\nrf_tls\mbedtls\dtls\config;..\..\external\nrf_tls\mbedtls\nrf_crypto\config;..\..\external\nrf_tls\mbedtls\tls\config;..\..\external\protothreads;..\..\external\protothreads\pt-1.4;..\..\external\segger_rtt;..\..\external\thedotfactory_fonts;..\..\external\tile\tile_lib;..\..\external\tile\tile_lib\crypto;..\..\external\tile\tile_lib\drivers;..\..\external\tile\tile_lib\modules;..\..\external\tile\tile_shim;..\..\external\tile\tile_shim\tile_assert;..\..\external\tile\tile_shim\tile_bdaddr;..\..\external\tile\tile_shim\tile_features;..\..\external\tile\tile_shim\tile_gatt_db;..\..\external\tile\tile_shim\tile_player;..\..\external\tile\tile_shim\tile_service;..\..\external\tile\tile_shim\tile_storage;..\..\external\utf_converter;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx;..\..\modules\nrfx\drivers;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\drivers\src;..\..\modules\nrfx\drivers\src\prs;..\..\modules\nrfx\hal;..\..\modules\nrfx\helpers;..\..\modules\nrfx\mdk;..\..\modules\nrfx\soc;..\..\modules\nrfx\templates;..\..\modules\nrfx\templates\nRF52832;..\..\project\config;..\..\project\mdk5\RTE;..\config;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\hal
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.0.0, Device:Startup 8.6.1
